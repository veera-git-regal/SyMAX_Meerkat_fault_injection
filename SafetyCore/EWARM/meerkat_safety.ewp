# IAR project meerkat_safety.ewp, settings and files
configuration meerkat_safety (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302R8 ST STM32F302R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=8000000; HSI_VALUE=8000000; LSI_VALUE=40000; VDD_VALUE=3300; PREFETCH_ENABLE=1; STM32F302x8
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: meerkat_safety.srec
  postbuild: "$EXE_DIR$\generate_crc.bat" "$TOOLKIT_DIR$"  "$TARGET_PATH$"
  ILINK.IlinkOutputFile: meerkat_safety.out
  ILINK.IlinkIcfFile: stm32f302x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f302x8.s
  group Application/Module
    ../Src/: adc_check.c clock_check.c ram_check.c register_check.c rom_check.c stm32g0xx_STLcpurunIAR.s
    ../Inc/: adc_check.h check_ids.h clock_check.h ram_check.h register_check.h rom_check.h
  group Application/User
    ../Src/: main.c safety_core_supervisor.c shared_ram.c shared_rom.c stm32f3xx_it.c
    ../Inc/: main.h safety_core_macros.h safety_core_ram_structures.h safety_core_supervisor.h shared_ram.h shared_rom.h stm32f3xx_it.h typedef.h
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_exti.c stm32f3xx_ll_gpio.c stm32f3xx_ll_utils.c
