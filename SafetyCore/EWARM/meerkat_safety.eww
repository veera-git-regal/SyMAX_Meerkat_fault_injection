<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\meerkat_safety.ewp</path>
  </project>
  <batchBuild />
</workspace>
